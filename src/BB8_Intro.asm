CLR
LD A 110	;;BODY TILE
LD &15 A
NOT A A
LD D 12
LD C 3
LD &D A		;;START LOOP CENTRE BODY
ADD D D 1
SUB C C 1
JNZ C 6		;;END LOOP CENTRE BODY
LD A 8
LD &16 A
LD A 20
LD &17 A
LD A 34
LD &18 A
LD A 65
LD &19 A
LD A 1		;;&20 DIRECTION
LD &20 A 
NOP 		;;HAD EXTRA LD BUT WAS NOT NEEDED
NOP 
LD A 16		;;&22 FRAME 16/17/18/19
LD &22 A
LD A 12		;;&23 COL
LD &23 A
NOP
LD A &22
LD A &A		;;						LABEL 4 / 5
LD C &23
AND B A 14	;;XXXXX111X MASK		LABEL 1
LD D &C
AND D D 241	;;11111XXX1 MASK
OR D B D
LD &C D
NOP
EQ B C 14
JNZ B 45	;;	lABEL 2
NOP
NOP ROR A A		;;	5A1000
NOP ROR A A		;;	5A1000
NOP ROR A A		;;	5A1000
ADD C C 1
PCL 30		;;	lABEL 1
NOP
LD A &22	;;						LABEL 2
EQ B A 19
JNZ B 52	;;	LABEL 3
ADD A A 1
LD &22 A
PCL 28		;;	lABEL 4
NOP
SUB A A 3	;;						LABEL 3
LD &22 A
PCL 28		;;	LABEL 5