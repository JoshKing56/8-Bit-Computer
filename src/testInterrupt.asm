CLR
PCU 0
PCL 34
NOP
NOP
NOP
NOP
NOP RIR1 B ; A10000
AND C B 1
JNZ C 18
RSH B B
AND C B 1
JNZ C 23
RSH B B
AND C B 1
JNZ C 28
LDI 
NOP
LD D &0
ADD D D 1
LD &0 D
PCL 10
NOP
LD D &1
ADD D D 1
LD &1 D
PCL 13
NOP
LD D &2
ADD D D 1
LD &2 D
PCL 16
NOP
NOP
LD A &15
ADD A A 1
LD &15 A
NOP
NOP
NOP
NOP
PCU 0
NOP
NOP
NOP
NOP
PCL 34